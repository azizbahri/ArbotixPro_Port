<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CM3_Peri</name>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\stm32f10x_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\stm32f10x_bkp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\stm32f10x_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\stm32f10x_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\stm32f10x_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\stm32f10x_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\stm32f10x_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\stm32f10x_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\stm32f10x_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\stm32f10x_fsmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\stm32f10x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\stm32f10x_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\stm32f10x_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\stm32f10x_lib.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\stm32f10x_nvic.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\stm32f10x_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\stm32f10x_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\stm32f10x_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\stm32f10x_sdio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\stm32f10x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\stm32f10x_systick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\stm32f10x_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\stm32f10x_tim1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\stm32f10x_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\stm32f10x_vector.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\stm32f10x_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>CM730_HW</name>
    <file>
      <name>$PROJ_DIR$\..\CM730\CM730_HW\src\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\CM730_HW\src\button.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\CM730_HW\src\gyro_acc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\CM730_HW\src\led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\CM730_HW\src\sound.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\CM730_HW\src\system_func.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\CM730_HW\src\system_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\CM730_HW\src\usart.c</name>
    </file>
  </group>
  <group>
    <name>CM730_SW</name>
    <file>
      <name>$PROJ_DIR$\..\CM730\CM730_APP\src\CM_DXL_COM.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\CM730_APP\src\isr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\CM730_APP\src\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\CM730_APP\src\serial.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\CM730_APP\src\stm32f10x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\CM730_APP\src\zgb_hal.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CM730\CM730_APP\src\zigbee.c</name>
    </file>
  </group>
  <group>
    <name>Utils</name>
    <file>
      <name>$PROJ_DIR$\..\CM730\stm32f10x_lib\src\cortexm3_macro.s</name>
    </file>
  </group>
</project>


