<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CM730_Old.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\darkholme.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\ExampleTemplate\Projects\main\EWARM\example.ewp</path>
  </project>
  <batchBuild/>
</workspace>


