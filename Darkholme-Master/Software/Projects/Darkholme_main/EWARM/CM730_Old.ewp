# IAR project CM730_Old.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: C:\Users\aziz\Documents\GitHub\Darkholme\Darkholme-Master\Software\Projects\darkholme_main\CM730\CM730_APP\inc; C:\Users\aziz\Documents\GitHub\Darkholme\Darkholme-Master\Software\Projects\darkholme_main\CM730\CM730_HW\inc; C:\Users\aziz\Documents\GitHub\Darkholme\Darkholme-Master\Software\Projects\darkholme_main\CM730\stm32f10x_lib\inc; C:\Users\aziz\Documents\GitHub\Darkholme\Darkholme-Master\Software\Projects\darkholme_main\CM730
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CM3_Peri
    ../CM730/stm32f10x_lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_tim1.c stm32f10x_usart.c stm32f10x_vector.c stm32f10x_wwdg.c
  group CM730_HW
    ../CM730/CM730_HW/src/: adc.c button.c gyro_acc.c led.c sound.c system_func.c system_init.c usart.c
  group CM730_SW
    ../CM730/CM730_APP/src/: CM_DXL_COM.c isr.c main.c serial.c stm32f10x_it.c zgb_hal.c zigbee.c
  group Utils
    ../CM730/stm32f10x_lib/src/: cortexm3_macro.s
